# Keil uVision project lpc55_lcd_dcore1.uvprojx, settings and files
target lpc55_lcd_dcore1 (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core1 NXP
  pack: NXP.LPC55S69_DFP.12.1.1
  cpu: CPUTYPE("Cortex-M33")
  output: lpc55_lcd_dcore1.out
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --bincombined_base=0x04000000 --output=$Lcore1_image.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_LPC55S69JBD100_cm33_core1, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: board;source;CMSIS;LPC55S69/arm;component/lists;component/serial_manager;component/uart;device;doc;drivers;mcmgr;startup;utilities;lcd
  asm define: CPU_LPC55S69JBD100_cm33_core1, DEBUG, KEIL, DEBUG, SLAVEBOOT, NO_CRP
  asm include: board;source;CMSIS;LPC55S69/arm;component/lists;component/serial_manager;component/uart;device;doc;drivers;mcmgr;startup;utilities;../lpc55_lcd_dcore0/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core1_ram.scf
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm33.h mpu_armv7.h mpu_armv8.h tz_context.h
  group component/uart
    component/serial_manager/: serial_port_uart.h serial_port_uart.c serial_port_internal.h serial_manager.h serial_manager.c
    component/lists/: generic_list.h generic_list.c
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core1.h LPC55S69_cm33_core1_features.h system_LPC55S69_cm33_core1.c system_LPC55S69_cm33_core1.h
    ./drivers/: fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h keil_lib_power_cm33_core1.lib
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_mailbox.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
    ./drivers/: fsl_dma.c fsl_dma.h fsl_gint.c fsl_gint.h fsl_pint.h fsl_pint.c fsl_inputmux_connections.h fsl_inputmux.c fsl_inputmux.h
  group mcmgr/doc
    mcmgr/doc/: all_0.html all_1.html all_2.html dir_68267d1309a1af8e8297ef4c3efbcdba.html enums_0.html enums_1.html enumvalues_0.html functions_0.html group__mcmgr.html groups_0.html index.html mcmgr_8h_source.html modules.html nomatches.html pages_0.html typedefs_0.html
  group mcmgr
    mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_lpc55s69.c readme.txt
  group source
    ./source/: main_core1.c
  group startup
    startup/: startup_LPC55S69_cm33_core1.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group lcd
    ./lcd/: lcd.c lcd.h lcd_fonts.c lcd_fonts.h

# Keil uVision project lpc55_lcd_dcore0.uvprojx, settings and files
target lpc55_lcd_dcore0 (6140000::V6.14::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lpc55_lcd_dcore0.out +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CORE1_IMAGE_COPY_TO_RAM, CPU_LPC55S69JBD100_cm33_core0, ARM_MATH_CM33, MCMGR_HANDLE_EXCEPTIONS=1, __SEMIHOST_HARDFAULT_DISABLE=1, MULTICORE_APP=1, SERIAL_PORT_TYPE_UART=1
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: board;source;CMSIS;LPC55S69/arm;component/lists;component/serial_manager;component/uart;device;doc;drivers;mcmgr;startup;utilities;lcd;emwin;.\emwin\emWin_Config;.\emwin\emWin_header
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: board;source;CMSIS;LPC55S69/arm;component/lists;component/serial_manager;component/uart;device;doc;drivers;mcmgr;startup;utilities;../lpc55_lcd_dcore1/debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: LPC55S69_cm33_core0_flash.scf
  link misc: --keep=*(.m0code)
  group board
    board/: clock_config.c clock_config.h pin_mux.c pin_mux.h
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_mailbox.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
    ./drivers/: keil_lib_power_cm33_core0.lib fsl_spi_dma.h fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_dma.h fsl_dma.c
  group mcmgr
    mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_lpc55s69.c readme.txt
  group source
    source/: hello_world_core0.c
    ./source/: ui_startpage.c ui_enrollface.c incbin.S ui_touch_calibration.c image_zhiwen150150.c image_nxplogo.c ui_face_display.c image_face_big.c image_face_little.c image_face_mid.c app_printf.h app_printf.c lpc_ring_buffer.h lpc_ring_buffer.c app.h app_interrupt.h app_interrupt.c
  group startup
    ./startup/: startup_LPC55S69_cm33_core0.S
  group lcd
    ./lcd/: lcd.c lcd.h lcd_fonts.c lcd_fonts.h
  group emwin
    ./emwin/emWin_Config/: GUIConf.h LCDConf.h
    ./emwin/: emwin_support.c emwin_support.h
    ./emwin/emWin_library/Keil/: emWin_M33.lib
